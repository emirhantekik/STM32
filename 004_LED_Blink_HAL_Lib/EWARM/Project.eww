<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\004_LED_Blink_HAL_Lib.ewp</path>
  </project>
  <batchBuild />
</workspace>
